## hello_world/build_flpr/vpr_launcher/Kconfig/boards/Kconfig.nrf54l15dk
```kconfig
# Load board Kconfig descriptions.
osource "C:/ncs/v2.9.0/zephyr/boards/nordic/nrf54l15dk/Kconfig.nrf54l15dk"
```
